# Keil uVision project iSO-STM32.uvproj, settings and files
target Finger (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Phriph;..\..\System\delay;..\..\System\sys;..\..\System\usart;..\..\System;..\..\Math;..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt
  group Periph
    ../../Phriph/: as608.c as608.h I2C_IO.c I2C_IO.h PN532_IIC.c PN532_IIC.h stm32_SPI_RC522.c stm32_SPI_RC522.h ESP8266_WIFI.c ESP8266_WIFI.h led.c led.h DH11.c DH11.h BMP280.c BMP280.h bsp_i2c_gpio.c bsp_i2c_gpio.h SIM900A.c SIM900A.h lock.c lock.h
  group System
    ../../System/delay/: delay.c delay.h
    ../../System/sys/: sys.c sys.h
    ../../System/: timer.c timer.h
    ../../System/usart/: usart3_v2.c usart3_v2.h usart2_v2.c usart2_v2.h usart1_v2.c usart1_v2.h
  group APP
    ../../APP/: Finger.c Finger.h RFID_IC.h RFID_IC.c Cmd_Ctrl.c Cmd_Ctrl.h Environment.c Environment.h LockApp.c LockApp.h
  group Math
    ../../Math/: BinarySearch.c BinarySearch.h Dec2BCD.c Dec2BCD.h Float2char.c Float2char.h
